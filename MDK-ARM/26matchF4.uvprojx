# Keil uVision project 26matchF4.uvprojx, settings and files
target 26matchF4 (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 26matchF4 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Bsp/Inc;../User/Algorithm/Inc;../User/Device/Inc;../User/App/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User/Device
    ../User/Device/Src/: DJI_Motor.c jy61p.c OLED.c sensor.c DM_Motor.c arm.c maixcam.c
    ../User/Device/Inc/: DJI_Motor.h jy61p.h OLED.h OLED_Font.h sensor.h DM_Motor.h arm.h maixcam.h
  group User/Bsp
    ../User/Bsp/Src/: bsp_can.c bsp_dwt.c
    ../User/Bsp/Inc/: bsp_dwt.h bsp_can.h
  group User/Algorithm
    ../User/Algorithm/Src/: pid.c user_lib.c
    ../User/Algorithm/Inc/: pid.h user_lib.h
  group User/App
    ../User/App/Src/: chassis.c task.c route.c
    ../User/App/Inc/: chassis.h task.h route.h
software components: CMSIS:CORE 6.2.0, CMSIS:DSP 1.17.0
